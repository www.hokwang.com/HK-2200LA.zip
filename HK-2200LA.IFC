Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-2200LA.IFC
Time: 2022-01-04T09:07:01
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 22外殼螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 出風口柵門3
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 外殼D
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 底座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 感應器-2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
